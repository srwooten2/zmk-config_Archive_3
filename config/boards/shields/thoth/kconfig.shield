## config/boards/shields/thoth/kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_THOTH
	def_bool $(shields_list_contains,thoth)
```
